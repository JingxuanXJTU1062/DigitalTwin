# Keil uVision project STM32_UART_CMD.uvprojx, settings and files
target STM32_PUL_WHILE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\APP;..\BSP;..\CMSIS;..\LIB\STM32F10x_StdPeriph_Lib_V3.5.0\inc;..\DRIVERS;..\VL53L0X;..\VL53L0X\core\inc;..\VL53L0X\platform\inc;..\VL53L0X\Driver;..\VL53L0X\User;..\Control\inc;..\vl53_app\inc;..\Hardware\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: main.c stm32f10x_conf.h stm32f10x_it.c
  group BSP
    ../BSP/: Emm_V5.c Emm_V5.h usart.c usart.h board.c board.h
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group DRIVERS
    ../DRIVERS/: fifo.c fifo.h delay.c delay.h
  group STM32F10x_StdPeriph_Lib_V3.5.0
    ../LIB/STM32F10x_StdPeriph_Lib_V3.5.0/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_exti.c
  group VL53L0X
    ../VL53L0X/: stm32_i2c.c vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_i2c.c vl53l0x_platform.c vl53l0x_platform_log.c
  group Control
    ../Control/: gripper_control.c
  group vl53_app
    ../vl53_app/: vl53_app.c
  group Hardware
    ../Hardware/: Motor.c PWM.c TTP223.c
